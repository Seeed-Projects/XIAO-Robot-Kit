#include "dance.h"

#include <math.h>
#include <stdbool.h>
#include <stddef.h>
#include <stdint.h>

#include "esp_log.h"
#include "esp_timer.h"
#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"
#include "freertos/task.h"

#include "arm_action.h"
#include "chassis_action.h"
#include "servo.h"
#include "speed_control.h"

#define DANCE_TASK_STACK_SIZE 4096
#define DANCE_TASK_PRIORITY 4
#define DANCE_CANCEL_TIMEOUT_MS 500
#define DANCE_SPEED 80
#define DANCE_INNER_TURN_SPEED 60
#define DANCE_STEP_DURATION_MS 250
#define DANCE_ARM_POSE_DURATION_MS 400
#define DANCE_FULL_SPIN_DURATION_MS 1100
#define DANCE_SPIN_LEAD_DURATION_MS 200
#define DANCE_SPIN_ARM_DURATION_MS \
    ((DANCE_FULL_SPIN_DURATION_MS - DANCE_SPIN_LEAD_DURATION_MS) / 2)
#define DANCE_CYCLES_PER_GROUP 3
#define DANCE_GROUP_COUNT 2
#define SWAY_BEAT_DURATION_MS 500
#define SWAY_CYCLES_PER_GROUP 4
#define SWAY_GROUP_COUNT 2
#define GREETING_SWING_DURATION_MS 120
#define GREETING_SWING_COUNT 3
#define HANDSHAKE_CENTER_ANGLE 90
#define HANDSHAKE_SWING_ANGLE 25
#define HANDSHAKE_SWING_DURATION_MS 180
#define DANCE_TAKEHAND_COUNT_IN_MS 673
#define DANCE_TAKEHAND_BEAT_MS 469
#define DANCE_TAKEHAND_SPIN_REST_MS \
    ((4 * DANCE_TAKEHAND_BEAT_MS) - DANCE_FULL_SPIN_DURATION_MS)

/* The current physical layout is Servo 1/J1 on the right and Servo 2/J5 on the left. */
#define DANCE_LEFT_ARM_SERVO_ID 2
#define DANCE_RIGHT_ARM_SERVO_ID 1
#define DANCE_LEFT_ARM_UP_ANGLE 0
#define DANCE_LEFT_ARM_DOWN_ANGLE 180
#define DANCE_RIGHT_ARM_UP_ANGLE 180
#define DANCE_RIGHT_ARM_DOWN_ANGLE 0
#define DANCE_ARM_KEEP_ANGLE (-1)

typedef struct {
    bool set_speed;
    bool set_arms;
    int left_speed;
    int right_speed;
    int left_arm_angle;
    int right_arm_angle;
    uint32_t duration_ms;
} dance_step_t;

typedef struct {
    const dance_step_t *cycle;
    size_t cycle_step_count;
    size_t cycles_per_group;
    size_t group_count;
    bool run_group_spin;
    bool set_arms_down_on_completion;
    uint32_t start_delay_ms;
} dance_program_t;

static const dance_step_t dance_cycle[] = {
    { true, false, DANCE_INNER_TURN_SPEED, DANCE_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_UP_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, -DANCE_INNER_TURN_SPEED, -DANCE_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_UP_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, DANCE_SPEED, DANCE_INNER_TURN_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_UP_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, -DANCE_SPEED, -DANCE_INNER_TURN_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_UP_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
};

/* Mirror the two forward arcs before returning to trace a horizontal figure eight. */
static const dance_step_t infinity_cycle[] = {
    { true, false, DANCE_INNER_TURN_SPEED, DANCE_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_UP_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, DANCE_SPEED, DANCE_INNER_TURN_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_UP_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, -DANCE_SPEED, -DANCE_INNER_TURN_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_UP_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, -DANCE_INNER_TURN_SPEED, -DANCE_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_UP_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
};

/* Gimbal-led call-and-response: a still cue precedes each side's body reply. */
static const dance_step_t echo_cycle[] = {
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, DANCE_INNER_TURN_SPEED, DANCE_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_UP_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, -DANCE_INNER_TURN_SPEED, -DANCE_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_UP_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, DANCE_SPEED, DANCE_INNER_TURN_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_UP_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
    { true, false, -DANCE_SPEED, -DANCE_INNER_TURN_SPEED, 0, 0,
      DANCE_STEP_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_ARM_POSE_DURATION_MS },
};

static const dance_step_t dance_spin[] = {
    { true, false, DANCE_SPEED, -DANCE_SPEED, 0, 0, DANCE_SPIN_LEAD_DURATION_MS },
    { false, true, 0, 0, DANCE_LEFT_ARM_UP_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      DANCE_SPIN_ARM_DURATION_MS },
    { false, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_UP_ANGLE,
      DANCE_SPIN_ARM_DURATION_MS },
};

/*
 * Take Me Hand: 128 BPM, 4/4. This choreography uses a 673 ms count-in so
 * the first move lands on the first downbeat, then runs 32 four-beat bars at
 * 469 ms per beat (60.705 s total). Each section has a distinct movement
 * phrase: wake-up, side steps, travel, build, chorus, spin accents and a
 * closed final pose. The left/right names below refer to physical arms, not
 * servo numbering.
 */

#define TAKEHAND_HALF_BEAT_A_MS (DANCE_TAKEHAND_BEAT_MS / 2)               /* 234 ms */
#define TAKEHAND_HALF_BEAT_B_MS (DANCE_TAKEHAND_BEAT_MS - TAKEHAND_HALF_BEAT_A_MS) /* 235 ms */

/* Wheel speeds are closed-loop percent targets (-100..100), per bar. */
#define TAKEHAND_SPEED_SOFT      46
#define TAKEHAND_SPEED_ROLL      58
#define TAKEHAND_SPEED_GLIDE     64
#define TAKEHAND_SPEED_ARC_INNER 30
#define TAKEHAND_SPEED_ARC_OUTER 68
#define TAKEHAND_SPEED_TWIST     62
#define TAKEHAND_SPEED_PIVOT     60
#define TAKEHAND_SPEED_SPIN      72
#define TAKEHAND_SPEED_SHIMMY    76

/* Five-level mirrored arm map: 120 degrees of usable travel (30..150). */
#define TAKEHAND_LEFT_ARM_DOWN_POSE  150
#define TAKEHAND_LEFT_ARM_LOW_POSE   128
#define TAKEHAND_LEFT_ARM_MID_POSE    90
#define TAKEHAND_LEFT_ARM_HIGH_POSE   52
#define TAKEHAND_LEFT_ARM_UP_POSE     30

#define TAKEHAND_RIGHT_ARM_DOWN_POSE  30
#define TAKEHAND_RIGHT_ARM_LOW_POSE   52
#define TAKEHAND_RIGHT_ARM_MID_POSE   90
#define TAKEHAND_RIGHT_ARM_HIGH_POSE 128
#define TAKEHAND_RIGHT_ARM_UP_POSE   150

/* Wheels keep their target through the second half; only the arm pose changes. */
#define TH_FLOW_BEAT(L_SPEED, R_SPEED, L1, R1, L2, R2) \
    { true,  true, L_SPEED, R_SPEED, L1, R1, TAKEHAND_HALF_BEAT_A_MS }, \
    { false, true, 0,       0,       L2, R2, TAKEHAND_HALF_BEAT_B_MS }

/* Two wheel targets inside one beat for body shakes and rapid reversals. */
#define TH_SWITCH_BEAT(L1_SPEED, R1_SPEED, A1L, A1R, \
                       L2_SPEED, R2_SPEED, A2L, A2R) \
    { true, true, L1_SPEED, R1_SPEED, A1L, A1R, TAKEHAND_HALF_BEAT_A_MS }, \
    { true, true, L2_SPEED, R2_SPEED, A2L, A2R, TAKEHAND_HALF_BEAT_B_MS }

#define TH_STOP_BEAT(L1, R1, L2, R2) \
    TH_FLOW_BEAT(0, 0, L1, R1, L2, R2)

/* 1. Closed wake-up, then each outside arm follows the direction of the turn. */
#define TAKEHAND_BAR_OPENING \
    TH_STOP_BEAT(TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_SOFT, TAKEHAND_SPEED_SOFT, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_SOFT, -TAKEHAND_SPEED_SOFT, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ROLL, TAKEHAND_SPEED_ROLL, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE)

/* 2. S curve: the arm on the outside of each curve opens as the body changes side. */
#define TAKEHAND_BAR_S_CURVE \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_INNER, TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_OUTER, TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_INNER, -TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_OUTER, -TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 3. Forward motion opens the body; reverse motion pulls both arms inward. */
#define TAKEHAND_BAR_ROLL_BACK \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ROLL, TAKEHAND_SPEED_ROLL, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_GLIDE, TAKEHAND_SPEED_GLIDE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_GLIDE, -TAKEHAND_SPEED_GLIDE, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ROLL, -TAKEHAND_SPEED_ROLL, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE)

/* 4. Directional turns: the outside arm reaches fully and the inside arm folds. */
#define TAKEHAND_BAR_TURN_FLAP \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_TWIST, TAKEHAND_SPEED_TWIST, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_TWIST, -TAKEHAND_SPEED_TWIST, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_SOFT, TAKEHAND_SPEED_SOFT, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_SOFT, -TAKEHAND_SPEED_SOFT, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_MID_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 5. The arm above the active wheel becomes the leading "step" accent. */
#define TAKEHAND_BAR_PIVOT_WALK \
    TH_FLOW_BEAT(0, TAKEHAND_SPEED_PIVOT, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_PIVOT, 0, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(0, -TAKEHAND_SPEED_PIVOT, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_PIVOT, 0, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_MID_POSE, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE)

/* 6. Left orbit: right/outside arm stays extended while the inside arm breathes. */
#define TAKEHAND_BAR_ORBIT_LEFT \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_INNER, TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_INNER, TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_INNER, TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_INNER, TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 7. Right orbit: exact mirror of TAKEHAND_BAR_ORBIT_LEFT. */
#define TAKEHAND_BAR_ORBIT_RIGHT \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_OUTER, TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_OUTER, TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_MID_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_OUTER, TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_MID_POSE, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_OUTER, TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 8. Diagonal propeller poses reverse together with the spin direction. */
#define TAKEHAND_BAR_SPIN_RETURN \
    TH_FLOW_BEAT(TAKEHAND_SPEED_SPIN, -TAKEHAND_SPEED_SPIN, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_SPIN, -TAKEHAND_SPEED_SPIN, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_SPIN, TAKEHAND_SPEED_SPIN, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_SPIN, TAKEHAND_SPEED_SPIN, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 9. Short opposing punches follow each half-beat chassis reversal. */
#define TAKEHAND_BAR_SHIMMY \
    TH_SWITCH_BEAT(-TAKEHAND_SPEED_SHIMMY, TAKEHAND_SPEED_SHIMMY, \
                   TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                   TAKEHAND_SPEED_SHIMMY, -TAKEHAND_SPEED_SHIMMY, \
                   TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE), \
    TH_SWITCH_BEAT(-TAKEHAND_SPEED_SHIMMY, TAKEHAND_SPEED_SHIMMY, \
                   TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                   TAKEHAND_SPEED_SHIMMY, -TAKEHAND_SPEED_SHIMMY, \
                   TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_SWITCH_BEAT(TAKEHAND_SPEED_SOFT, TAKEHAND_SPEED_SOFT, \
                   TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                   -TAKEHAND_SPEED_SOFT, -TAKEHAND_SPEED_SOFT, \
                   TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE), \
    TH_SWITCH_BEAT(-TAKEHAND_SPEED_TWIST, TAKEHAND_SPEED_TWIST, \
                   TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                   TAKEHAND_SPEED_TWIST, -TAKEHAND_SPEED_TWIST, \
                   TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE)

/* 10. Reverse serpentine uses a pulling/scooping arm action. */
#define TAKEHAND_BAR_BACK_WAVE \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_INNER, -TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_MID_POSE, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_OUTER, -TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_INNER, -TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_OUTER, -TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 11. Forward serpentine opens toward the outside of each curve. */
#define TAKEHAND_BAR_FORWARD_WAVE \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_OUTER, TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_INNER, TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_OUTER, TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_INNER, TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_MID_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 12. Pivot, forward reach, opposite pivot, then fold on the reverse step. */
#define TAKEHAND_BAR_CROSS_STEP \
    TH_FLOW_BEAT(0, TAKEHAND_SPEED_PIVOT, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_GLIDE, TAKEHAND_SPEED_GLIDE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_PIVOT, 0, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_GLIDE, -TAKEHAND_SPEED_GLIDE, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE)

/* 13. Right-hand invitation: left arm balances low while the right reaches twice. */
#define TAKEHAND_BAR_INVITE_RIGHT \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_INNER, TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_MID_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_INNER, TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_OUTER, -TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_OUTER, -TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 14. Left-hand invitation: mirrored response to TAKEHAND_BAR_INVITE_RIGHT. */
#define TAKEHAND_BAR_INVITE_LEFT \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_OUTER, TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_ARC_OUTER, TAKEHAND_SPEED_ARC_INNER, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_INNER, -TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_ARC_INNER, -TAKEHAND_SPEED_ARC_OUTER, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 15. Wings open with forward motion and fold with reverse motion. */
#define TAKEHAND_BAR_WINGS \
    TH_FLOW_BEAT(TAKEHAND_SPEED_SOFT, TAKEHAND_SPEED_SOFT, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_SOFT, -TAKEHAND_SPEED_SOFT, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_SOFT, TAKEHAND_SPEED_SOFT, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_SOFT, -TAKEHAND_SPEED_SOFT, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 16. Strong accents: diagonal hit, spin-open, forward-open/back-close, reverse hit. */
#define TAKEHAND_BAR_HIT_COMBO \
    TH_SWITCH_BEAT(-TAKEHAND_SPEED_SHIMMY, TAKEHAND_SPEED_SHIMMY, \
                   TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                   TAKEHAND_SPEED_SHIMMY, -TAKEHAND_SPEED_SHIMMY, \
                   TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_SPIN, -TAKEHAND_SPEED_SPIN, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_SWITCH_BEAT(TAKEHAND_SPEED_GLIDE, TAKEHAND_SPEED_GLIDE, \
                   TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE, \
                   -TAKEHAND_SPEED_GLIDE, -TAKEHAND_SPEED_GLIDE, \
                   TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_SPIN, TAKEHAND_SPEED_SPIN, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_MID_POSE, TAKEHAND_RIGHT_ARM_MID_POSE)

/* 17. Final phrase: open forward, directional turns, then a full-width hold. */
#define TAKEHAND_BAR_FINAL \
    TH_FLOW_BEAT(TAKEHAND_SPEED_GLIDE, TAKEHAND_SPEED_GLIDE, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(-TAKEHAND_SPEED_TWIST, TAKEHAND_SPEED_TWIST, \
                 TAKEHAND_LEFT_ARM_LOW_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_UP_POSE), \
    TH_FLOW_BEAT(TAKEHAND_SPEED_TWIST, -TAKEHAND_SPEED_TWIST, \
                 TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_LOW_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE), \
    TH_STOP_BEAT(TAKEHAND_LEFT_ARM_HIGH_POSE, TAKEHAND_RIGHT_ARM_HIGH_POSE, \
                 TAKEHAND_LEFT_ARM_UP_POSE, TAKEHAND_RIGHT_ARM_UP_POSE)

static const dance_step_t takehand_cycle[] = {
    { true, true, 0, 0, TAKEHAND_LEFT_ARM_DOWN_POSE, TAKEHAND_RIGHT_ARM_DOWN_POSE,
      DANCE_TAKEHAND_COUNT_IN_MS },

    /* Arduino v1.4.0's 32-bar Take My Hand choreography. */
    TAKEHAND_BAR_OPENING,
    TAKEHAND_BAR_S_CURVE,
    TAKEHAND_BAR_ROLL_BACK,
    TAKEHAND_BAR_TURN_FLAP,
    TAKEHAND_BAR_PIVOT_WALK,
    TAKEHAND_BAR_ORBIT_LEFT,
    TAKEHAND_BAR_ORBIT_RIGHT,
    TAKEHAND_BAR_SPIN_RETURN,

    TAKEHAND_BAR_SHIMMY,
    TAKEHAND_BAR_BACK_WAVE,
    TAKEHAND_BAR_FORWARD_WAVE,
    TAKEHAND_BAR_CROSS_STEP,
    TAKEHAND_BAR_INVITE_RIGHT,
    TAKEHAND_BAR_WINGS,
    TAKEHAND_BAR_INVITE_LEFT,
    TAKEHAND_BAR_HIT_COMBO,

    TAKEHAND_BAR_ORBIT_RIGHT,
    TAKEHAND_BAR_ORBIT_LEFT,
    TAKEHAND_BAR_PIVOT_WALK,
    TAKEHAND_BAR_ROLL_BACK,
    TAKEHAND_BAR_SHIMMY,
    TAKEHAND_BAR_INVITE_RIGHT,
    TAKEHAND_BAR_BACK_WAVE,
    TAKEHAND_BAR_SPIN_RETURN,

    TAKEHAND_BAR_FORWARD_WAVE,
    TAKEHAND_BAR_CROSS_STEP,
    TAKEHAND_BAR_WINGS,
    TAKEHAND_BAR_TURN_FLAP,
    TAKEHAND_BAR_S_CURVE,
    TAKEHAND_BAR_INVITE_LEFT,
    TAKEHAND_BAR_HIT_COMBO,
    TAKEHAND_BAR_FINAL,
};

#undef TH_FLOW_BEAT
#undef TH_SWITCH_BEAT
#undef TH_STOP_BEAT
#undef TAKEHAND_BAR_OPENING
#undef TAKEHAND_BAR_S_CURVE
#undef TAKEHAND_BAR_ROLL_BACK
#undef TAKEHAND_BAR_TURN_FLAP
#undef TAKEHAND_BAR_PIVOT_WALK
#undef TAKEHAND_BAR_ORBIT_LEFT
#undef TAKEHAND_BAR_ORBIT_RIGHT
#undef TAKEHAND_BAR_SPIN_RETURN
#undef TAKEHAND_BAR_SHIMMY
#undef TAKEHAND_BAR_BACK_WAVE
#undef TAKEHAND_BAR_FORWARD_WAVE
#undef TAKEHAND_BAR_CROSS_STEP
#undef TAKEHAND_BAR_INVITE_RIGHT
#undef TAKEHAND_BAR_INVITE_LEFT
#undef TAKEHAND_BAR_WINGS
#undef TAKEHAND_BAR_HIT_COMBO
#undef TAKEHAND_BAR_FINAL

/* This chassis needs a stronger PID target to overcome floor static friction. */
#define BELIEVER_SPEED_SOFT 55
#define BELIEVER_SPEED_STEP 55
#define BELIEVER_SPEED_ARC_INNER 48
#define BELIEVER_SPEED_ARC_OUTER 82
#define BELIEVER_SPEED_TWIST 82
#define BELIEVER_SPEED_SHAKE 92
/*
 * Keep each translational beat deliberately compact for the 80 cm stage.
 * The PID target remains high enough to overcome static friction, then the
 * chassis stops for the rest of the beat. Opposite-wheel spin beats are not
 * shortened, so turns and the finale retain their visual impact.
 */
#define BELIEVER_TRANSLATION_ACTIVE_PERCENT 60
#define BELIEVER_YAW_SAMPLE_PERIOD_MS 10
#define BELIEVER_HEADING_RETURN_DEADBAND_DEGREES 3.0f
#define BELIEVER_HEADING_RETURN_TIMEOUT_MS 12000

/* Mirrored 30..150 degree arm travel keeps clear of the installed stops. */
#define BELIEVER_LEFT_ARM_DOWN_POSE 150
#define BELIEVER_LEFT_ARM_LOW_POSE 128
#define BELIEVER_LEFT_ARM_MID_POSE 90
#define BELIEVER_LEFT_ARM_HIGH_POSE 52
#define BELIEVER_LEFT_ARM_UP_POSE 30

#define BELIEVER_RIGHT_ARM_DOWN_POSE 30
#define BELIEVER_RIGHT_ARM_LOW_POSE 52
#define BELIEVER_RIGHT_ARM_MID_POSE 90
#define BELIEVER_RIGHT_ARM_HIGH_POSE 128
#define BELIEVER_RIGHT_ARM_UP_POSE 150

static const dance_step_t believer_cycle[] = {
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 238 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 238 },
    { true, true, -BELIEVER_SPEED_SOFT, -BELIEVER_SPEED_SOFT, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 232 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 238 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 238 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 226 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 227 },

    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 476 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 458 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 465 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 470 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 464 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 470 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 459 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 453 },

    { true, true, -BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 487 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 459 },
    { true, true, BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 476 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 453 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 238 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 702 },
    { true, true, -BELIEVER_SPEED_SOFT, -BELIEVER_SPEED_SOFT, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 696 },

    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 470 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 459 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 464 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 470 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 465 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 470 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 453 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 470 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 470 },

    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 447 },
    { true, true, -BELIEVER_SPEED_SOFT, -BELIEVER_SPEED_SOFT, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 494 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 458 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 470 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 465 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 464 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 470 },

    { true, true, -BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 459 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 470 },
    { true, true, BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 470 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 465 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 229 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 700 },
    { true, true, -BELIEVER_SPEED_SOFT, -BELIEVER_SPEED_SOFT, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 235 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 688 },

    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 452 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 471 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 464 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 482 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 476 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 458 },
    { true, true, BELIEVER_SPEED_SOFT, BELIEVER_SPEED_SOFT, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 476 },
    { true, true, -BELIEVER_SPEED_SOFT, -BELIEVER_SPEED_SOFT, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 453 },

    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 238 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 238 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 232 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 229 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 229 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 232 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },

    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 464 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 476 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 459 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 452 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 476 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 471 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 470 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 464 },
    { true, true, BELIEVER_SPEED_SOFT, BELIEVER_SPEED_SOFT, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 235 },
    { false, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 235 },
    { true, true, -BELIEVER_SPEED_SOFT, -BELIEVER_SPEED_SOFT, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 302 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 336 },
};

/*
 * New Believer (New_Believer35.mp3): 128.7 BPM, 4/4. The beat grid was fitted
 * to the measured drum onsets of the MP3 (first beat 46 ms after the audible
 * start, 466.05 ms per beat), and the kick/clap accents below land on the
 * actual measured drum hits. 19 bars, about 35.9 s: verse side-arc groove
 * while the vocal runs (bars 1-8), a crouched break (bar 9), the instrumental
 * drop with twists, kick punches and paired full spins (bars 10-17), a
 * 16th-note shake build (bar 18) and an arms-up outro pose (bar 19). Twist
 * and spin directions are balanced in pairs so the chassis ends the dance
 * close to its starting heading. Wheel speeds reuse the stage-tuned
 * BELIEVER_SPEED_* targets; keep this table in sync with the MP3.
 */
static const dance_step_t new_believer_cycle[] = {
    /* bar 1 - verse (0.05s) */
    { true, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 117 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 116 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 117 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 116 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 117 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 349 },
    /* bar 2 - verse (1.91s) */
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 117 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 116 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 117 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 349 },
    /* bar 3 - verse (3.77s) */
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 234 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    /* bar 4 - verse (5.64s) */
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    /* bar 5 - verse (7.50s) */
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    /* bar 6 - verse (9.37s) */
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    /* bar 7 - verse (11.23s) */
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    /* bar 8 - verse (13.10s) */
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, BELIEVER_SPEED_ARC_OUTER, BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 234 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_OUTER, -BELIEVER_SPEED_ARC_INNER, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    /* bar 9 - break (14.96s) */
    { true, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 932 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 466 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    /* bar 10 - drop (16.82s) */
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 116 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 117 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    /* bar 11 - drop (18.69s) */
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 117 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 116 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    /* bar 12 - drop (20.55s) */
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 466 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 466 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 117 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 116 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    /* bar 13 - drop (22.42s) */
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 234 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 116 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 117 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    /* bar 14 - drop (24.28s) */
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 466 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 466 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    /* bar 15 - drop (26.14s) */
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 116 },
    { true, true, BELIEVER_SPEED_STEP, BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 117 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_LOW_POSE, 233 },
    { true, true, -BELIEVER_SPEED_STEP, -BELIEVER_SPEED_STEP, BELIEVER_LEFT_ARM_LOW_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 233 },
    /* bar 16 - drop (28.01s) */
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 466 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 466 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 117 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 116 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, -BELIEVER_SPEED_TWIST, BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    /* bar 17 - drop (29.87s) */
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 466 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 466 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_MID_POSE, BELIEVER_RIGHT_ARM_MID_POSE, 233 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 233 },
    { true, true, BELIEVER_SPEED_TWIST, -BELIEVER_SPEED_TWIST, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 233 },
    /* bar 18 - final build (31.74s) */
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 117 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 116 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 117 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 116 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 117 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 116 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 117 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 117 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 116 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_DOWN_POSE, 117 },
    { true, true, BELIEVER_SPEED_SHAKE, -BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 116 },
    { true, true, -BELIEVER_SPEED_SHAKE, BELIEVER_SPEED_SHAKE, BELIEVER_LEFT_ARM_DOWN_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 117 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 932 },
    /* bar 19 - outro (33.60s) */
    { true, true, BELIEVER_SPEED_ARC_INNER, BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_HIGH_POSE, BELIEVER_RIGHT_ARM_HIGH_POSE, 466 },
    { true, true, -BELIEVER_SPEED_ARC_INNER, -BELIEVER_SPEED_ARC_OUTER, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 466 },
    { true, true, 0, 0, BELIEVER_LEFT_ARM_UP_POSE, BELIEVER_RIGHT_ARM_UP_POSE, 900 },
};

/* One eight-beat sway: left forward/back, then right forward/back. */
static const dance_step_t sway_cycle[] = {
    { true, false, DANCE_INNER_TURN_SPEED, DANCE_SPEED, 0, 0, SWAY_BEAT_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_UP_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      SWAY_BEAT_DURATION_MS },
    { true, false, -DANCE_INNER_TURN_SPEED, -DANCE_SPEED, 0, 0, SWAY_BEAT_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      SWAY_BEAT_DURATION_MS },
    { true, false, DANCE_SPEED, DANCE_INNER_TURN_SPEED, 0, 0, SWAY_BEAT_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_UP_ANGLE,
      SWAY_BEAT_DURATION_MS },
    { true, false, -DANCE_SPEED, -DANCE_INNER_TURN_SPEED, 0, 0, SWAY_BEAT_DURATION_MS },
    { true, true, 0, 0, DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      SWAY_BEAT_DURATION_MS },
};

/* Right-arm-only gestures leave the left arm in its current position. */
static const dance_step_t greeting_cycle[] = {
    { false, true, 0, 0, DANCE_ARM_KEEP_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      GREETING_SWING_DURATION_MS },
    { false, true, 0, 0, DANCE_ARM_KEEP_ANGLE, DANCE_RIGHT_ARM_UP_ANGLE,
      GREETING_SWING_DURATION_MS },
    { false, true, 0, 0, DANCE_ARM_KEEP_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE,
      GREETING_SWING_DURATION_MS },
};

static const dance_step_t handshake_cycle[] = {
    { false, true, 0, 0, DANCE_ARM_KEEP_ANGLE, HANDSHAKE_CENTER_ANGLE,
      HANDSHAKE_SWING_DURATION_MS },
    { false, true, 0, 0, DANCE_ARM_KEEP_ANGLE,
      HANDSHAKE_CENTER_ANGLE + HANDSHAKE_SWING_ANGLE, HANDSHAKE_SWING_DURATION_MS },
    { false, true, 0, 0, DANCE_ARM_KEEP_ANGLE,
      HANDSHAKE_CENTER_ANGLE - HANDSHAKE_SWING_ANGLE, HANDSHAKE_SWING_DURATION_MS },
    { false, true, 0, 0, DANCE_ARM_KEEP_ANGLE,
      HANDSHAKE_CENTER_ANGLE + HANDSHAKE_SWING_ANGLE, HANDSHAKE_SWING_DURATION_MS },
    { false, true, 0, 0, DANCE_ARM_KEEP_ANGLE,
      HANDSHAKE_CENTER_ANGLE - HANDSHAKE_SWING_ANGLE, HANDSHAKE_SWING_DURATION_MS },
    { false, true, 0, 0, DANCE_ARM_KEEP_ANGLE, HANDSHAKE_CENTER_ANGLE,
      HANDSHAKE_SWING_DURATION_MS },
};

static const dance_program_t dance_program = {
    .cycle = dance_cycle,
    .cycle_step_count = sizeof(dance_cycle) / sizeof(dance_cycle[0]),
    .cycles_per_group = DANCE_CYCLES_PER_GROUP,
    .group_count = DANCE_GROUP_COUNT,
    .run_group_spin = true,
    .set_arms_down_on_completion = true,
};

static const dance_program_t infinity_program = {
    .cycle = infinity_cycle,
    .cycle_step_count = sizeof(infinity_cycle) / sizeof(infinity_cycle[0]),
    .cycles_per_group = DANCE_CYCLES_PER_GROUP,
    .group_count = DANCE_GROUP_COUNT,
    .run_group_spin = true,
    .set_arms_down_on_completion = true,
};

static const dance_program_t echo_program = {
    .cycle = echo_cycle,
    .cycle_step_count = sizeof(echo_cycle) / sizeof(echo_cycle[0]),
    .cycles_per_group = DANCE_CYCLES_PER_GROUP,
    .group_count = DANCE_GROUP_COUNT,
    .run_group_spin = true,
    .set_arms_down_on_completion = true,
};

static const dance_program_t takehand_program = {
    .cycle = takehand_cycle,
    .cycle_step_count = sizeof(takehand_cycle) / sizeof(takehand_cycle[0]),
    .cycles_per_group = 1,
    .group_count = 1,
    .run_group_spin = false,
    .set_arms_down_on_completion = true,
};

static const dance_program_t believer_program = {
    .cycle = believer_cycle,
    .cycle_step_count = sizeof(believer_cycle) / sizeof(believer_cycle[0]),
    .cycles_per_group = 1,
    .group_count = 1,
    .run_group_spin = false,
    .set_arms_down_on_completion = true,
    .start_delay_ms = 0,
};

static const dance_program_t new_believer_program = {
    .cycle = new_believer_cycle,
    .cycle_step_count = sizeof(new_believer_cycle) / sizeof(new_believer_cycle[0]),
    .cycles_per_group = 1,
    .group_count = 1,
    .run_group_spin = false,
    .set_arms_down_on_completion = true,
    /* Covers the phone music player's start latency: the skill issues this
       command in the same round as playMusic, so the bar-1 clap lands on the
       music's first clap. Calibrate in 100 ms steps on the real phone. */
    .start_delay_ms = 900,
};

static const dance_program_t sway_program = {
    .cycle = sway_cycle,
    .cycle_step_count = sizeof(sway_cycle) / sizeof(sway_cycle[0]),
    .cycles_per_group = SWAY_CYCLES_PER_GROUP,
    .group_count = SWAY_GROUP_COUNT,
    .run_group_spin = true,
    .set_arms_down_on_completion = true,
};

static const dance_program_t greeting_program = {
    .cycle = greeting_cycle,
    .cycle_step_count = sizeof(greeting_cycle) / sizeof(greeting_cycle[0]),
    .cycles_per_group = GREETING_SWING_COUNT,
    .group_count = 1,
    .run_group_spin = false,
    .set_arms_down_on_completion = false,
};

static const dance_program_t handshake_program = {
    .cycle = handshake_cycle,
    .cycle_step_count = sizeof(handshake_cycle) / sizeof(handshake_cycle[0]),
    .cycles_per_group = 1,
    .group_count = 1,
    .run_group_spin = false,
    .set_arms_down_on_completion = false,
};

static SemaphoreHandle_t dance_mutex;
static SemaphoreHandle_t dance_completion;
static TaskHandle_t dance_task;
static bool dance_cancelled;
static const char *TAG = "dance";

static esp_err_t dance_set_arm_angles(int left_arm_angle, int right_arm_angle)
{
    esp_err_t left_err = left_arm_angle == DANCE_ARM_KEEP_ANGLE ? ESP_OK :
        servo_set_angle(DANCE_LEFT_ARM_SERVO_ID, left_arm_angle);
    esp_err_t right_err = right_arm_angle == DANCE_ARM_KEEP_ANGLE ? ESP_OK :
        servo_set_angle(DANCE_RIGHT_ARM_SERVO_ID, right_arm_angle);
    return left_err != ESP_OK ? left_err : right_err;
}

static void dance_set_arms_down(void)
{
    (void)dance_set_arm_angles(DANCE_LEFT_ARM_DOWN_ANGLE, DANCE_RIGHT_ARM_DOWN_ANGLE);
}

static bool dance_is_cancelled(void)
{
    xSemaphoreTake(dance_mutex, portMAX_DELAY);
    bool cancelled = dance_cancelled;
    xSemaphoreGive(dance_mutex);
    return cancelled;
}

static void dance_track_heading(float *yaw_degrees, int64_t *previous_sample_us,
                                bool *tracking_enabled)
{
    if (!*tracking_enabled) {
        return;
    }

    float yaw_rate_dps;
    esp_err_t err = chassis_action_read_calibrated_yaw_rate(&yaw_rate_dps);
    if (err != ESP_OK) {
        *tracking_enabled = false;
        ESP_LOGW(TAG, "Heading tracking disabled: %s", esp_err_to_name(err));
        return;
    }

    int64_t now_us = esp_timer_get_time();
    *yaw_degrees += yaw_rate_dps * (float)(now_us - *previous_sample_us) / 1000000.0f;
    *previous_sample_us = now_us;
}

static bool dance_wait_step(uint32_t duration_ms, float *yaw_degrees,
                            int64_t *previous_sample_us, bool *tracking_enabled)
{
    int64_t deadline_us = esp_timer_get_time() + (int64_t)duration_ms * 1000;
    while (esp_timer_get_time() < deadline_us) {
        int64_t remaining_us = deadline_us - esp_timer_get_time();
        uint32_t wait_ms = (uint32_t)(remaining_us / 1000);
        if (wait_ms > BELIEVER_YAW_SAMPLE_PERIOD_MS) {
            wait_ms = BELIEVER_YAW_SAMPLE_PERIOD_MS;
        }
        if (wait_ms == 0) {
            wait_ms = 1;
        }
        if (ulTaskNotifyTake(pdTRUE, pdMS_TO_TICKS(wait_ms)) != 0) {
            return false;
        }
        if (yaw_degrees != NULL) {
            dance_track_heading(yaw_degrees, previous_sample_us, tracking_enabled);
        }
    }
    return !dance_is_cancelled();
}

static bool dance_step_is_translation(const dance_step_t *step)
{
    if (!step->set_speed || step->left_speed == 0 || step->right_speed == 0) {
        return false;
    }

    return (step->left_speed > 0 && step->right_speed > 0) ||
           (step->left_speed < 0 && step->right_speed < 0);
}

static uint32_t dance_translation_active_ms(uint32_t duration_ms)
{
    uint32_t active_ms = (duration_ms * BELIEVER_TRANSLATION_ACTIVE_PERCENT) / 100;
    return active_ms == 0 ? 1 : active_ms;
}

static bool dance_run_step(const dance_step_t *step, float *yaw_degrees,
                           int64_t *previous_sample_us, bool *tracking_enabled)
{
    xSemaphoreTake(dance_mutex, portMAX_DELAY);
    bool cancelled = dance_cancelled;
    esp_err_t err = ESP_OK;
    if (!cancelled && step->set_speed) {
        err = speed_control_set_target(step->left_speed, step->right_speed);
    }
    if (!cancelled && err == ESP_OK && step->set_arms) {
        err = dance_set_arm_angles(step->left_arm_angle, step->right_arm_angle);
    }
    xSemaphoreGive(dance_mutex);

    if (cancelled || err != ESP_OK) {
        return false;
    }

    if (dance_step_is_translation(step)) {
        uint32_t active_ms = dance_translation_active_ms(step->duration_ms);
        if (!dance_wait_step(active_ms, yaw_degrees, previous_sample_us, tracking_enabled)) {
            speed_control_stop();
            return false;
        }

        speed_control_stop();
        return dance_wait_step(step->duration_ms - active_ms, yaw_degrees,
                               previous_sample_us, tracking_enabled);
    }

    return dance_wait_step(step->duration_ms, yaw_degrees, previous_sample_us, tracking_enabled);
}

static float dance_normalize_heading(float yaw_degrees)
{
    float heading_error_degrees = fmodf(yaw_degrees, 360.0f);
    if (heading_error_degrees > 180.0f) {
        heading_error_degrees -= 360.0f;
    } else if (heading_error_degrees < -180.0f) {
        heading_error_degrees += 360.0f;
    }
    return heading_error_degrees;
}

static bool dance_return_believer_to_initial_heading(float dance_yaw_degrees)
{
    float heading_error_degrees = dance_normalize_heading(dance_yaw_degrees);

    if (fabsf(heading_error_degrees) < BELIEVER_HEADING_RETURN_DEADBAND_DEGREES) {
        ESP_LOGI(TAG, "Believer heading drift %.1f deg is within the deadband",
                 (double)heading_error_degrees);
        return true;
    }

    /* Turn opposite to the accumulated yaw through the shortest angular path. */
    float target_turn_degrees = fabsf(heading_error_degrees);
    int turn_speed = heading_error_degrees > 0.0f ? -BELIEVER_SPEED_SHAKE
                                                  : BELIEVER_SPEED_SHAKE;
    esp_err_t err = speed_control_set_target(turn_speed, -turn_speed);
    if (err != ESP_OK) {
        ESP_LOGW(TAG, "Believer heading return could not start: %s", esp_err_to_name(err));
        return false;
    }

    float returned_degrees = 0.0f;
    int64_t previous_sample_us = esp_timer_get_time();
    int64_t deadline_us = previous_sample_us +
                          (int64_t)BELIEVER_HEADING_RETURN_TIMEOUT_MS * 1000;
    while (esp_timer_get_time() < deadline_us) {
        if (dance_is_cancelled()) {
            speed_control_stop();
            return false;
        }
        vTaskDelay(pdMS_TO_TICKS(BELIEVER_YAW_SAMPLE_PERIOD_MS));

        float yaw_rate_dps;
        err = chassis_action_read_calibrated_yaw_rate(&yaw_rate_dps);
        if (err != ESP_OK) {
            speed_control_stop();
            ESP_LOGW(TAG, "Believer heading return stopped: %s", esp_err_to_name(err));
            return false;
        }
        int64_t now_us = esp_timer_get_time();
        returned_degrees += yaw_rate_dps * (float)(now_us - previous_sample_us) / 1000000.0f;
        previous_sample_us = now_us;
        if (fabsf(returned_degrees) >= target_turn_degrees) {
            speed_control_stop();
            ESP_LOGI(TAG, "Believer heading restored: error %.1f deg, shortest return %.1f deg",
                     (double)heading_error_degrees, (double)returned_degrees);
            return true;
        }
    }

    speed_control_stop();
    ESP_LOGW(TAG, "Believer heading return timed out at %.1f of %.1f deg",
             (double)returned_degrees, (double)target_turn_degrees);
    return false;
}

static bool dance_restore_believer_heading(float dance_yaw_degrees, bool tracking_enabled)
{
    speed_control_stop();
    if (!tracking_enabled) {
        ESP_LOGW(TAG, "Believer heading return skipped: IMU tracking unavailable");
        return true;
    }

    return dance_return_believer_to_initial_heading(dance_yaw_degrees);
}

static void dance_task_entry(void *arg)
{
    const dance_program_t *program = arg;
    bool completed = true;
    bool tracking_believer_yaw = program == &believer_program ||
                                 program == &new_believer_program;
    float believer_yaw_degrees = 0.0f;
    int64_t previous_yaw_sample_us = esp_timer_get_time();

    if (program->start_delay_ms > 0) {
        completed = dance_wait_step(program->start_delay_ms, NULL, &previous_yaw_sample_us,
                                    &tracking_believer_yaw);
        previous_yaw_sample_us = esp_timer_get_time();
    }

    for (size_t group = 0; group < program->group_count && completed; ++group) {
        for (size_t cycle = 0; cycle < program->cycles_per_group && completed; ++cycle) {
            for (size_t step = 0; step < program->cycle_step_count; ++step) {
                completed = dance_run_step(&program->cycle[step],
                                           tracking_believer_yaw ? &believer_yaw_degrees : NULL,
                                           &previous_yaw_sample_us, &tracking_believer_yaw);
                if (!completed) {
                    break;
                }
            }
        }

        if (completed && program->run_group_spin) {
            for (size_t step = 0; step < sizeof(dance_spin) / sizeof(dance_spin[0]); ++step) {
                completed = dance_run_step(&dance_spin[step], NULL, &previous_yaw_sample_us,
                                           &tracking_believer_yaw);
                if (!completed) {
                    break;
                }
            }
        }
    }

    if (completed && (program == &believer_program || program == &new_believer_program)) {
        completed = dance_restore_believer_heading(believer_yaw_degrees,
                                                   tracking_believer_yaw);
    }

    xSemaphoreTake(dance_mutex, portMAX_DELAY);
    if (!dance_cancelled) {
        speed_control_stop();
    }
    if (program->set_arms_down_on_completion || dance_cancelled) {
        dance_set_arms_down();
    }
    dance_task = NULL;
    xSemaphoreGive(dance_mutex);
    xSemaphoreGive(dance_completion);
    vTaskDelete(NULL);
}

esp_err_t dance_init(void)
{
    if (dance_mutex != NULL && dance_completion != NULL) {
        return ESP_OK;
    }

    if (dance_mutex == NULL) {
        dance_mutex = xSemaphoreCreateMutex();
        if (dance_mutex == NULL) {
            return ESP_ERR_NO_MEM;
        }
    }
    if (dance_completion == NULL) {
        dance_completion = xSemaphoreCreateBinary();
        if (dance_completion == NULL) {
            return ESP_ERR_NO_MEM;
        }
    }
    return ESP_OK;
}

static esp_err_t dance_start_program(const dance_program_t *program, const char *task_name)
{
    if (dance_mutex == NULL) {
        return ESP_ERR_INVALID_STATE;
    }

    xSemaphoreTake(dance_mutex, portMAX_DELAY);
    if (dance_task != NULL) {
        xSemaphoreGive(dance_mutex);
        return ESP_ERR_INVALID_STATE;
    }

    while (xSemaphoreTake(dance_completion, 0) == pdTRUE) {
    }
    speed_control_stop();
    dance_cancelled = false;
    if (xTaskCreate(dance_task_entry, task_name, DANCE_TASK_STACK_SIZE, (void *)program,
                    DANCE_TASK_PRIORITY, &dance_task) != pdPASS) {
        dance_task = NULL;
        xSemaphoreGive(dance_mutex);
        return ESP_ERR_NO_MEM;
    }
    xSemaphoreGive(dance_mutex);
    return ESP_OK;
}

esp_err_t dance_start(void)
{
    return dance_start_program(&dance_program, "dance");
}

esp_err_t dance_start_infinity(void)
{
    return dance_start_program(&infinity_program, "dance_infinity");
}

esp_err_t dance_start_echo(void)
{
    return dance_start_program(&echo_program, "dance_echo");
}

esp_err_t dance_start_take_me_hand(void)
{
    return dance_start_program(&takehand_program, "dance_takehand");
}

esp_err_t dance_start_believer(void)
{
    return dance_start_program(&believer_program, "dance_believer");
}

esp_err_t dance_start_new_believer(void)
{
    return dance_start_program(&new_believer_program, "new_believer");
}

esp_err_t dance_start_sway(void)
{
    return dance_start_program(&sway_program, "sway");
}

esp_err_t dance_start_greeting(void)
{
    return dance_start_program(&greeting_program, "greeting");
}

esp_err_t dance_start_handshake(void)
{
    return dance_start_program(&handshake_program, "handshake");
}

esp_err_t dance_cancel(void)
{
    if (dance_mutex == NULL || dance_completion == NULL) {
        return ESP_ERR_INVALID_STATE;
    }

    xSemaphoreTake(dance_mutex, portMAX_DELAY);
    dance_cancelled = true;
    TaskHandle_t task = dance_task;
    if (task != NULL) {
        xTaskNotifyGive(task);
        speed_control_stop();
        dance_set_arms_down();
    }
    xSemaphoreGive(dance_mutex);

    return task == NULL ||
                   xSemaphoreTake(dance_completion, pdMS_TO_TICKS(DANCE_CANCEL_TIMEOUT_MS)) == pdTRUE
               ? ESP_OK
               : ESP_ERR_TIMEOUT;
}

bool dance_is_active(void)
{
    if (dance_mutex == NULL) {
        return false;
    }

    xSemaphoreTake(dance_mutex, portMAX_DELAY);
    bool active = dance_task != NULL;
    xSemaphoreGive(dance_mutex);
    return active;
}

void dance_stop(void)
{
    (void)dance_cancel();
}
